# IAR project Zigbee_node.ewp, settings and files
configuration Zigbee_node (ARM, debug)
  General.OGChipSelectEditMenu: STM32L051C8 ST STM32L051C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L051xx; AC_BOARDx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ../service/DA_service; ../service/Data_service; ../service/Mesh_service; ../service/Shell_service; ../service/Shell_service/Shell; ../service/Shell_service/log; ../modules/event; ../modules/queue; ../modules/timer; ../modules/printf; ../modules/crc; ../modules/flash; ../modules/packet; ../modules/RN8209D
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: zigbee_node-dt1.1-v1.0.2r.hex
  ILINK.IlinkOutputFile: Zigbee_node.out
  ILINK.IlinkIcfFile: stm32l051xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/DA_service
    ../service/DA_service/: service_DA.c service_DA.h
  group Application/Data_service
    ../service/Data_service/: service_Data.c service_Data.h
  group Application/EWARM
    ./: startup_stm32l051xx.s
  group Application/Mesh_service
    ../service/Mesh_service/: service_Mesh.c service_Mesh.h
  group Application/Modules/crc
    ../modules/crc/: CRC.h CRC8_CCITT.c
  group Application/Modules/event
    ../modules/event/: event.c event.h
  group Application/Modules/flash
    ../modules/flash/: flash.c flash.h flash_table.h
  group Application/Modules/packet
    ../modules/packet/: packet.c packet.h
  group Application/Modules/printf
    ../modules/printf/: printf-stdarg.c printf-stdarg.h
  group Application/Modules/queue
    ../modules/queue/: queue.c queue.h
  group Application/Modules/RN8209
    ../modules/RN8209D/: RN8209.c RN8209.h RN8209_cfg.h
  group Application/Modules/timer
    ../modules/timer/: timer.c timer.h
  group Application/Shell_service
    ../service/Shell_service/: service_Shell.c service_Shell.h
  group Application/Shell_service/log
    ../service/Shell_service/log/: log.c log.h
  group Application/Shell_service/Shell
    ../service/Shell_service/Shell/: shell.c shell.h shell_call.c shell_call.h
  group Application/User
    ../Src/: adc.c dma.c gpio.c main.c rtc.c stm32l0xx_hal_msp.c stm32l0xx_it.c tim.c usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
